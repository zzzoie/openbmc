FILESEXTRAPATHS_prepend := "${THISDIR}/files/defconfig-5.6-delta/${SOC_MODEL}:"
SRC_URI += "file://defconfig \
           "
